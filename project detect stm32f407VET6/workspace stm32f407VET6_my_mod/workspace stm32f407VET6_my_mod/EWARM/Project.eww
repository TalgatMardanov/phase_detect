<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\workspace stm32f407VET6_my_mod.ewp</path>
  </project>
  <batchBuild />
</workspace>
